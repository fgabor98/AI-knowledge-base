SUMMARY = "Example product tools"
inherit packagegroup

RDEPENDS:${PN} = " \
    board-tool \
"
