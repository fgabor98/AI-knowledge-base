# Product delta for a recipe owned by OE-Core: replace /etc/issue.
FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
